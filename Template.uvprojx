# Keil uVision project Template.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: .\User;.\Libraries\CMSIS;.\Libraries\STM32F10x_StdPeriph_Driver\inc;.\APP\led;.\Public;.\APP\beep;.\APP\smg;.\APP\key;.\APP\leddz;.\APP\dc_motor;.\APP\step_motor;.\APP\exti;.\APP\time;.\APP\pwm;.\APP\default_MCU_Pin_Setup;.\APP\DF_Player;.\APP\HP9170;.\APP\timer;.\APP\74HC595;.\APP\iic;.\APP\24Cxx;.\APP\HP9200;.\APP\ds18b20
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ./User/: main.c stm32f10x_it.c
  group Startup
    ./Libraries/CMSIS/: startup_stm32f10x_md.s
  group StdPeriph_Driver
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_gpio.c stm32f10x_rcc.c misc.c stm32f10x_exti.c stm32f10x_tim.c stm32f10x_usart.c
  group CMSIS
    ./Libraries/CMSIS/: system_stm32f10x.c core_cm3.c
  group APP
    ./APP/default_MCU_Pin_Setup/: pin_Config.c
    ./APP/led/: led.c
    ./APP/HP9170/: HP9170.c
    ./APP/DF_Player/: DF_Player.c
    ./APP/timer/: timer.c
    ./APP/74HC595/: 74HC595.c
    ./APP/iic/: iic.c
    ./APP/24Cxx/: 24cxx.c
    ./APP/HP9200/: HP9200.c
    ./APP/ds18b20/: ds18b20.c
  group Public
    ./Public/: system.c SysTick.c usart.c
